# Repository itsnoteasy/discipline_iso_fork

File README.md:

# discipline_iso_fork
I'm not the creator of this board, I just changed it a little. see: https://github.com/coseyfannitutti/discipline

apologies for the missing diode beside the left shift switch, it's fixed now.

## KiCad design discipline_iso/discipline-pcb.kicad_pcb

File discipline_iso/README.md:

# DISCIPLINE
 65% keyboard assembled with only through hole components, including usb type-c

[BOM, Build Guide, and Flashing Information](./doc)

Ansi (lol) kits available at [cftkb.com](https://www.cftkb.com)

Parts:
BOOT1: BOOT; SW_PUSH_6mm
C1, C2: 22p; C_Disc_D3.0mm_W1.6mm_P2.50mm
C3: 4.7u; CP_Radial_D4.0mm_P1.50mm
C4, C5: 0.1u; C_Disc_D4.3mm_W1.9mm_P5.00mm
D1, D2, D3, D4, D5, D6, D7, D8, D9, D10, D11, D12, D13, D14, D15, D16, D17, D18, D19, D20, D21, D22, D23, D24, D25, D26, D27, D28, D29, D30, D31, D32, D33, D34, D35, D36, D37, D38, D39, D40, D41, D42, D43, D44, D45, D46, D47, D48, D49, D50, D51, D52, D53, D54, D55, D56, D57, D58, D59, D60, D61, D62, D63, D64, D65, D66, D67, D68: D_DO-35_SOD27_P5.08mm_Horizontal
D69, D70: 3.6V; D_DO-35_SOD27_P5.08mm_Horizontal
D690: D_T-1_P5.08mm_Horizontal
F1: 500mA; polyfuse_5.1mm
J1: AVR-ISP-6; PinHeader_2x03_P2.54mm_Vertical
LED1: POWER; LED_D3.0mm
R1, R2: 5.1k; R_Axial_DIN0204_L3.6mm_D1.6mm_P7.62mm_Horizontal
R3, R4: 75R; R_Axial_DIN0204_L3.6mm_D1.6mm_P7.62mm_Horizontal
R5: 1.5k; R_Axial_DIN0204_L3.6mm_D1.6mm_P7.62mm_Horizontal
R6: 1.5K; R_Axial_DIN0204_L3.6mm_D1.6mm_P7.62mm_Horizontal
R7: 10k; R_Axial_DIN0204_L3.6mm_D1.6mm_P7.62mm_Horizontal
RESET1: RESET; SW_PUSH_6mm
SW1, SW2, SW3, SW4, SW5, SW6, SW7, SW8, SW9, SW10, SW11, SW12, SW13, SW15, SW17, SW18, SW19, SW20, SW21, SW22, SW23, SW24, SW25, SW26, SW27, SW28, SW30, SW32, SW33, SW34, SW35, SW36, SW37, SW38, SW39, SW40, SW41, SW42, SW43, SW44, SW46, SW47, SW48, SW49, SW50, SW51, SW52, SW53, SW54, SW55, SW57, SW58, SW62, SW65, SW66, SW67, SW68, SW69, SW620: KEYSW; SW_Cherry_MX_1.00u_PCB
SW14: KEYSW; SW_Cherry_MX_2.00u_PCB
SW16: KEYSW; SW_Cherry_MX_1.50u_PCB
SW29: KEYSW; SW_Cherry_MX_ISOEnter_PCB
SW31, SW45, SW59, SW60, SW61, SW63, SW64, SW590, SW610, SW630, SW640: KEYSW; SW_Cherry_MX_1.25u_PCB
SW56, SW310: KEYSW; SW_Cherry_MX_1.75u_PCB
U1: ATmega32A-PU; DIP-40_W15.24mm
USB1: USB_C_GCT_USB4085
Y1: Crystal; Crystal_HC49-4H_Vertical

Connections:
+5V: C3.1, C4.1, C5.1, F1.1, J1.2 (VCC), LED1.2 (A), R5.1, R7.1, U1.10 (VCC), U1.30 (AVCC)
D+: R4.1, U1.16 (PD2)
D-: R3.1, U1.17 (PD3)
GND: BOOT1.1, C1.2, C2.2, C3.2, C4.2, C5.2, D69.2 (A), D70.2 (A), J1.6 (GND), R1.1, R2.2, R6.2, RESET1.1, U1.11 (GND), U1.31 (GND), USB1.A1 (GND), USB1.A12 (GND), USB1.B1 (GND), USB1.B12 (GND), USB1.S1 (SHIELD)
MISO: J1.1 (MISO), U1.7 (PB6)
MOSI: J1.4 (MOSI), U1.6 (PB5)
unnamed: C1.1, U1.13 (XTAL1), Y1.1
unnamed: C2.1, U1.12 (XTAL2), Y1.2
unnamed: D1.2 (A), SW1.2
unnamed: D2.2 (A), SW2.2
unnamed: D3.2 (A), SW3.2
unnamed: D4.2 (A), SW4.2
unnamed: D5.2 (A), SW5.2
unnamed: D6.2 (A), SW6.2
unnamed: D7.2 (A), SW7.2
unnamed: D8.2 (A), SW8.2
unnamed: D9.2 (A), SW9.2
unnamed: D10.2 (A), SW10.2
unnamed: D11.2 (A), SW11.2
unnamed: D12.2 (A), SW12.2
unnamed: D13.2 (A), SW13.2
unnamed: D14.2 (A), SW14.2
unnamed: D15.2 (A), SW15.2
unnamed: D16.2 (A), SW16.2
unnamed: D17.2 (A), SW17.2
unnamed: D18.2 (A), SW18.2
unnamed: D19.2 (A), SW19.2
unnamed: D20.2 (A), SW20.2
unnamed: D21.2 (A), SW21.2
unnamed: D22.2 (A), SW22.2
unnamed: D23.2 (A), SW23.2
unnamed: D24.2 (A), SW24.2
unnamed: D25.2 (A), SW25.2
unnamed: D26.2 (A), SW26.2
unnamed: D27.2 (A), SW27.2
unnamed: D28.2 (A), SW28.2
unnamed: D29.2 (A), SW29.2
unnamed: D30.2 (A), SW30.2
unnamed: D31.2 (A), SW31.2, SW310.2
unnamed: D32.2 (A), SW32.2
unnamed: D33.2 (A), SW33.2
unnamed: D34.2 (A), SW34.2
unnamed: D35.2 (A), SW35.2
unnamed: D36.2 (A), SW36.2
unnamed: D37.2 (A), SW37.2
unnamed: D38.2 (A), SW38.2
unnamed: D39.2 (A), SW39.2
unnamed: D40.2 (A), SW40.2
unnamed: D41.2 (A), SW41.2
unnamed: D42.2 (A), SW42.2
unnamed: D43.2 (A), SW43.2
unnamed: D44.2 (A), SW44.2
unnamed: D45.2 (A), SW45.2
unnamed: D46.2 (A), SW46.2
unnamed: D47.2 (A), SW47.2
unnamed: D48.2 (A), SW48.2
unnamed: D49.2 (A), SW49.2
unnamed: D50.2 (A), SW50.2
unnamed: D51.2 (A), SW51.2
unnamed: D52.2 (A), SW52.2
unnamed: D53.2 (A), SW53.2
unnamed: D54.2 (A), SW54.2
unnamed: D55.2 (A), SW55.2
unnamed: D56.2 (A), SW56.2
unnamed: D57.2 (A), SW57.2
unnamed: D58.2 (A), SW58.2
unnamed: D59.2 (A), SW59.2, SW590.2
unnamed: D60.2 (A), SW60.2
unnamed: D61.2 (A), SW61.2, SW610.2
unnamed: D62.2 (A), SW62.2, SW620.2
unnamed: D63.2 (A), SW63.2, SW630.2
unnamed: D64.2 (A), SW64.2, SW640.2
unnamed: D65.2 (A), SW65.2
unnamed: D66.2 (A), SW66.2
unnamed: D67.2 (A), SW67.2
unnamed: D68.2 (A), SW68.2
unnamed: D69.1 (K), R3.2, R5.2, USB1.A7 (DN1), USB1.B7 (DN2)
unnamed: D70.1 (K), R4.2, USB1.A6 (DP1), USB1.B6 (DP2)
unnamed: D690.2 (A), SW69.2
unnamed: LED1.1 (K), R6.1
unnamed: R1.2, USB1.A5 (CC1)
unnamed: R2.1, USB1.B5 (CC2)
SCK: J1.3 (SCK), U1.8 (PB7)
VCC: F1.2, USB1.A4 (VBUS), USB1.A9 (VBUS), USB1.B4 (VBUS), USB1.B9 (VBUS)
boot: BOOT1.2, U1.18 (PD4)
col0: SW1.1, SW16.1, SW31.1, SW45.1, SW59.1, SW310.1, SW590.1, U1.38 (PA2)
col1: SW2.1, SW17.1, SW32.1, SW60.1, SW69.1, U1.4 (PB3)
col2: SW3.1, SW18.1, SW33.1, SW46.1, SW61.1, SW610.1, U1.37 (PA3)
col3: SW4.1, SW19.1, SW34.1, SW47.1, U1.5 (PB4)
col4: SW5.1, SW20.1, SW35.1, SW48.1, U1.36 (PA4)
col5: SW6.1, SW21.1, SW36.1, SW49.1, U1.19 (PD5)
col6: SW7.1, SW22.1, SW37.1, SW50.1, SW62.1, SW620.1, U1.20 (PD6)
col7: SW8.1, SW23.1, SW38.1, SW51.1, U1.28 (PC6)
col8: SW9.1, SW24.1, SW39.1, SW52.1, U1.27 (PC5)
col9: SW10.1, SW25.1, SW40.1, SW53.1, SW63.1, SW630.1, U1.26 (PC4)
col10: SW11.1, SW26.1, SW41.1, SW54.1, SW64.1, SW640.1, U1.25 (PC3)
col11: SW12.1, SW27.1, SW42.1, SW55.1, SW68.1, U1.24 (PC2)
col12: SW13.1, SW28.1, SW56.1, SW65.1, U1.23 (PC1)
col13: SW14.1, SW29.1, SW43.1, SW57.1, SW66.1, U1.22 (PC0)
col14: SW15.1, SW30.1, SW44.1, SW58.1, SW67.1, U1.21 (PD7)
reset: J1.5 (~RST), R7.2, RESET1.2, U1.9 (~RESET)
row0: D1.1 (K), D2.1 (K), D3.1 (K), D4.1 (K), D5.1 (K), D6.1 (K), D7.1 (K), D8.1 (K), D9.1 (K), D10.1 (K), D11.1 (K), D12.1 (K), D13.1 (K), D14.1 (K), D15.1 (K), U1.3 (PB2)
row1: D16.1 (K), D17.1 (K), D18.1 (K), D19.1 (K), D20.1 (K), D21.1 (K), D22.1 (K), D23.1 (K), D24.1 (K), D25.1 (K), D26.1 (K), D27.1 (K), D28.1 (K), D29.1 (K), D30.1 (K), U1.39 (PA1)
row2: D31.1 (K), D32.1 (K), D33.1 (K), D34.1 (K), D35.1 (K), D36.1 (K), D37.1 (K), D38.1 (K), D39.1 (K), D40.1 (K), D41.1 (K), D42.1 (K), D43.1 (K), D44.1 (K), U1.2 (PB1)
row3: D45.1 (K), D46.1 (K), D47.1 (K), D48.1 (K), D49.1 (K), D50.1 (K), D51.1 (K), D52.1 (K), D53.1 (K), D54.1 (K), D55.1 (K), D56.1 (K), D57.1 (K), D58.1 (K), D690.1 (K), U1.40 (PA0)
row4: D59.1 (K), D60.1 (K), D61.1 (K), D62.1 (K), D63.1 (K), D64.1 (K), D65.1 (K), D66.1 (K), D67.1 (K), D68.1 (K), U1.1 (PB0)

Notes on the sheet:
DISCIPLINE // 65% keyboard with only through hole components
7/1/2019
DISCIPLINE

Board: 2 copper layers, 304.9 x 122.8 mm, 168 parts (1 on the bottom side), 106 nets.

Other parts of the board:
ST62: 6.25U; MX-6.25U-Stabilizer
ST62#2: 7U; MX-7U-Stabilizer
